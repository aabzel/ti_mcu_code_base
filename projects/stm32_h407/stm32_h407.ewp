# IAR project stm32_h407.ewp, settings and files
configuration stm32_h407 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: HAS_CLI; HAS_CORTEX_M4; HAS_DEBUG; HAS_GPIO; HAS_IAR; HAS_LORA; HAS_INTERRUPT; HAS_MCU; HAS_SPI; HAS_SPI2; HAS_SX1262; HAS_SX1262_DEBUG; HAS_TASKS; HAS_UART; HAS_USART6; NORTOS; STM32F407xx; STM32F4xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ../../boards/stm32_H407; ../../bsp_stm32f4/clocks; ../../bsp_stm32f4/core_drv; ../../bsp_stm32f4/flash_nvs; ../../bsp_stm32f4/flash; ../../bsp_stm32f4/gpio; ../../bsp_stm32f4/spi; ../../bsp_stm32f4/tim; ../../bsp_stm32f4/uart; ../../bsp_stm32f4; ../../CMSIS/Device/ST/STM32F4xx/Include; ../../CMSIS/Include; ../../common; ../../components/system; ../../Drivers/boot_drv; ../../Drivers/cli_drv; ../../Drivers/flash_fs; ../../Drivers/params; ../../Drivers/task_drv; ../../Drivers; ../../STM32F4xx_HAL_Driver/Inc/Legacy; ../../STM32F4xx_HAL_Driver/Inc; ../../utils/crc; ../../utils/fifo; ../../utils/io_utils; ../../utils/utils_math; ../../utils/utils_string; ../../utils/utils_sys; ../../utils; ../..; Core; $PROJ_DIR$; ..\..\bsp_stm32f4\interrupt; ..\..\bsp_stm32f4\spi; ..\..\Drivers\sx1262; ..\..\Drivers; ..\..\Drivers\lora
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32_h407.bin
  ILINK.IlinkOutputFile: stm32_h407.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: main.c
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    Core/: gpio.c sdio.c stm32f4xx_hal_msp.c
  group boards/stm32_H407
    ../../boards/stm32_H407/: board_layout.c board_layout.h board_stm32_h407.h
  group bsp_stm32
    ../../bsp_stm32f4/: stm32f4xx_it.c sys.c
  group bsp_stm32/clocks
    ../../bsp_stm32f4/clocks/: clocks.c sys_tick.c
  group bsp_stm32/core
    ../../bsp_stm32f4/core_drv/: core_commands.c core_driver.c
  group bsp_stm32/flash
    ../../bsp_stm32f4/flash/: flash_drv.c
  group bsp_stm32/gpio
    ../../bsp_stm32f4/gpio/: gpio_commands.c gpio_commands.h gpio_diag.c gpio_diag.h gpio_drv.c gpio_drv.h
  group bsp_stm32/interrupt
    ../../bsp_stm32f4/interrupt/: interrupt_drv.c
  group bsp_stm32/spi
    ../../bsp_stm32f4/spi/: spi_commands.c spi_commands.h spi_drv.c spi_drv.h
  group bsp_stm32/uart
    ../../bsp_stm32f4/uart/: uart_commands.c uart_drv.c
  group CMSIS
    ../../CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group common
    ../../common/: common_functions.c core_utils.c hw_init.c spi_common.c sw_init.c uart_common.c
  group components/system
    ../../components/system/: system.c
  group Drivers/boot
    ../../Drivers/boot_drv/: boot_driver.c
  group Drivers/cli_drv
    ../../Drivers/cli_drv/: base_cmd.c cli_manager.c log_commands.c table_utils.c
  group Drivers/flash_fs
    ../../Drivers/flash_fs/: flash_fs.c flash_fs_commands.c flash_fs_ll.c
  group Drivers/flash_nvs
    ../../bsp_stm32f4/flash_nvs/: flash_nvs_drv.c
  group Drivers/LoRa
    ../../Drivers/lora/: lora_commands.c lora_commands.h lora_defs.h lora_drv.c lora_drv.h
  group Drivers/params
    ../../Drivers/params/: param_ids.c
  group Drivers/sx1262
    ../../Drivers/sx1262/: gfsk_defs.h legal_band.c legal_band.h sx1262_commands.c sx1262_commands.h sx1262_config.h sx1262_diag.c sx1262_diag.h sx1262_drv.c sx1262_drv.h sx1262_op_codes.h
  group Drivers/task_drv
    ../../Drivers/task_drv/: task_commands.c task_info.c
  group STM32F4xx_HAL_Driver
    ../../STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_sdmmc.c
  group utils
    ../../utils/: array.c bit_utils.c byte_utils.c data_utils.c debug_info.c float_utils.c health_monitor.c health_monitor_command.c none_blocking_pause.c read_mem.c time_utils.c
  group utils/crc
    ../../utils/crc/: crc16_ccitt.c crc24_q.c crc32.c crc8_autosar.c crc8_sae_j1850.c
  group utils/fifo
    ../../utils/fifo/: fifo_array.c fifo_char.c fifo_index.c
  group utils/io_utils
    ../../utils/io_utils/: io_utils.c log.c oprintf.c ostream.c print_format.c string_writer.c uart_string_reader.c writer_config.c writer_generic.c writer_uart.c
  group utils/utils_string
    ../../utils/utils_string/: convert.c str_utils.c
  group utils/utils_sys
    ../../utils/utils_sys/: device_id.c diag_sys.c
