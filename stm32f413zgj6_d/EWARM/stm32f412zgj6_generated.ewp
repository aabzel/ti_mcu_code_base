# IAR project stm32f412zgj6_generated.ewp, settings and files
configuration stm32f412zgj6_generated (ARM, debug)
  General.OGChipSelectEditMenu: STM32F413ZG ST STM32F413ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F413xx; HAS_EXT_RAM_EMUL; HAS_SPI; HAS_FLASH; HAS_GPIO; HAS_RTC; HAS_SPI1; HAS_TIM; HAS_CLI; HAS_HEALTH_MONITOR; HAS_UART
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../../bsp_stm32f4\clocks; ../../bsp_stm32f4\gpio; ../../bsp_stm32f4\uart; ../../bsp_stm32f4\spi; ../../bsp_stm32f4\tim; ..\..\common; ..\..; ..\..\utils\io_utils; ..\..\utils\utils_string; ..\..\utils; ..\..\bsp_stm32f4; ..; ..\..\Drivers\cli_drv; ..\..\bsp_stm32f4\rtc; ..\..\utils\utils_sys; ..\..\utils\crc; ..\..\bsp_stm32f4\core_drv; ..\..\bsp_stm32f4\flash; ..\..\Drivers\mx25l6433f; ..\..\Drivers\ext_ram_simulator
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: stm32f412zgj6_generated.hex
  ILINK.IlinkOutputFile: stm32f412zgj6_generated.out
  ILINK.IlinkIcfFile: stm32f413xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f413xx.s
  group Application/User/Core
    ../Core/Src/: freertos_init.c main.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c
  group bsp_stm32f4
    ../../bsp_cc26x2/: sys.c
  group bsp_stm32f4/clock
    ../../bsp_stm32f4/clocks/: clock_commands.c clocks.c
  group bsp_stm32f4/core
    ../../bsp_stm32f4/core_drv/: core_commands.c core_driver.c
  group bsp_stm32f4/flash
    ../../bsp_stm32f4/flash/: flash_commands.c flash_commands.h flash_drv.c flash_drv.h
  group bsp_stm32f4/gpio
    ../../bsp_stm32f4/gpio/: gpio_commands.c gpio_drv.c
  group bsp_stm32f4/rtc
    ../../bsp_stm32f4/rtc/: rtc_commands.c rtc_drv.c
  group bsp_stm32f4/spi
    ../../bsp_stm32f4/spi/: spi_commands.c spi_drv.c
  group bsp_stm32f4/tim
    ../../bsp_stm32f4/tim/: tim_commands.c tim_drv.c
  group bsp_stm32f4/uart
    ../../bsp_stm32f4/uart/: uart_commands.c uart_drv.c
  group common
    ../../common/: common_functions.c hw_init.c sw_init.c
  group Drivers/cli_drv
    ../../Drivers/cli_drv/: base_cmd.c cli_manager.c log_commands.c table_utils.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/ext_ram_emul
    ../../Drivers/ext_ram_simulator/: ext_ram_sim_commands.c ext_ram_sim_drv.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group utils
    ../../utils/: bit_utils.c byte_utils.c data_utils.c debug_info.c fifo_char_buffer.c fifo_index.c float_utils.c health_monitor.c health_monitor_command.c read_mem.c
  group utils/crc
    ../../utils/crc/: crc16_ccitt.c crc32.c crc8_autosar.c crc8_sae_j1850.c
  group utils/io_utils
    ../../utils/io_utils/: io_utils.c log.c oprintf.c ostream.c print_format.c string_writer.c uart_string_reader.c writer_generic.c writer_uart.c
  group utils/utils_string
    ../../utils/utils_string/: convert.c str_utils.c
  group utils/utils_sys
    ../../utils/utils_sys/: diag_sys.c
